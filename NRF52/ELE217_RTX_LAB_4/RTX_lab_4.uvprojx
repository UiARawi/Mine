# Keil uVision project RTX_lab_4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTX_lab_3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52 NRF52832_XXAA BOARD_PCA10040
  c include: ..\ELE217_RTX_LAB_4;..\..\..\config;..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\modules\nrfx\drivers\include;..\..\..\components\libraries\atomic;..\..\..\components\libraries\balloc;..\..\..\components\libraries\bsp;..\..\..\components\libraries\delay;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\libraries\memobj;..\..\..\components\libraries\ringbuf;..\..\..\components\libraries\strerror;..\..\..\components\libraries\util;..\..\..\modules\nrfx;..\..\..\modules\nrfx\hal;..\..\..\modules\nrfx\mdk;..\..\..\integration\nrfx;..\..\..\components\boards;..\..\..\modules\nrfx\drivers\include;..\..\..\integration\nrfx\legacy
  asm define: NRF52 NRF52832_XXAA BOARD_PCA10040
  asm include: ..\ELE217_RTX_LAB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: lamp_control.c lamp_control.h main.c sdk_config.h print_server.c print_server.h switch_monitor.c switch_monitor.h SVC_Table.s
  group Board definitions
    ../../../components/boards/: boards.c boards.h
  group nRFDrivers
    ../../../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_gpiote.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS:Keil RTX 4.81.1, Device:Startup 8.24.1
