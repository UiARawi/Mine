# Keil uVision project CON_LAB_3.uvprojx, settings and files
target nRF52832 DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.30.2
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTX_LAB_1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52   NRF52832_XXAA   BOARD_PCA10040
  c include: ..\Slave_nRF;..\..\..\components\boards;..\..\..\modules\nrfx;..\..\..\modules\nrfx\hal;..\..\..\components\libraries\util;..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\modules\nrfx\drivers\inclu de;..\..\..\integration\nrfx;..\..\..\integration\nrfx\legacy;..\..\..\..\..\nRF5_SDK_15_3_0\components\libraries\util;..\..\..\modules\nrfx\drivers\include;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\libraries\experimental_section_vars;..\..\..\integration\nrfx\legacy;..\..\..\components\libraries\delay;..\..\..\components\libraries\pwr_mgmt;..\..\..\components\libraries\mutex;..\..\..\components\libraries\atomic;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\strerror;..\..\..\components\libraries\memobj;..\..\..\components\libraries\balloc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c sdk_config.h print_server.c print_server.h switch_monitor.c switch_monitor.h DEFINES.h Twi_fx.c Twi_fx.h SPI.c SPI.h
  group Board definition
    ../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../components/libraries/util/: app_util_platform.c
  group nRF_Drivers
    ../../../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_gpiote.c nrfx_ppi.c nrfx_saadc.c nrfx_timer.c nrfx_uarte.c nrfx_twi.c nrfx_twim.c nrfx_spis.c nrfx_spim.c nrfx_spi.c
    ../../../integration/nrfx/legacy/: nrf_drv_ppi.c nrf_drv_uart.c nrf_drv_twi.c nrf_drv_spis.c
    ../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../components/libraries/atomic/: nrf_atomic.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS:Keil RTX 4.81.1, Device:Startup 8.24.1
